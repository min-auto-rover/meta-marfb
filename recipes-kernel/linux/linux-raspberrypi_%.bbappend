FILESEXTRAPATHS:prepend := "${THISDIR}/linux-raspberrypi-custom:"
SRC_URI:append = " file://myconfig.cfg"

