FILESEXTRAPATHS:prepend := "${THISDIR}/linux-yocto-custom:"
SRC_URI:append = " file://myconfig.cfg"

